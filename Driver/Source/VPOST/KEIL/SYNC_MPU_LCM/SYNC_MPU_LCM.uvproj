# Keil uVision project SYNC_MPU_LCM.uvproj, settings and files
target SYNC_MPU_LCM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_VPOST_LCM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __HAVE_SYNC_MPU_LCMD0__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../: N9H26_VPOST.c N9H26_VPOST_Driver.c N9H26_VPOST_LCM_Init.c N9H26_VPOST_Mpu_LCM.c N9H26_VPOST_Sync_LCM.c
