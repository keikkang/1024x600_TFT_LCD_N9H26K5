# Keil uVision project VPOST_N9H26_LCM.uvproj, settings and files
target N9H26K6_LCM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: VPOST
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __LCD_800x480__
  c include: ..\ASIC;..\..\..\Driver\Include;..\LCM_INIT;..\ASIC;..\..\Driver\Include;..\..\Library\IPLib
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: ..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: standalone.c wb_init.s main.c
  group Lib
    ../../Library/IPLib/: N9H26_SYS.lib N9H26_VPOST_LCM.lib
